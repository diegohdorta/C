# Copyright 2018 NXP

SUMMARY = "Scikit Learn"
DESCRIPTION = "ML"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[md5sum] = "f91feb99601785fb2e6661349b696240"
SRC_URI[sha256sum] = "b276739a5f863ccacb61999a3067d0895ee291c95502929b2ae56ea1f882e888"


HOMEPAGE = "https://pypi.org/project/scikit-learn/"

inherit pypi setuptools3








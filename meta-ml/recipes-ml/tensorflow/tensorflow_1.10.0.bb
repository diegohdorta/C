# Copyright 2018 NXP

SUMMARY = "Tensorflow"
DESCRIPTION = "ML"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT"



HOMEPAGE = "https://pypi.org/project/tensorflow/"

inherit pypi setuptools3

